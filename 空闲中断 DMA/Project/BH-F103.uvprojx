# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Sys\systick;..\Sys\usart;..\Bsp;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
    ../App/: app_usart.c
  group BSP
    ../Bsp/: bsp_led.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
    ../../使用函数指针优化 中断接收数据/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c
  group SYS
    ../Sys/systick/: systick.c
    ../Sys/usart/: usart.c
  group DOC
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.5.0
